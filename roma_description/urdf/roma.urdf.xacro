Commit message: fix: Corrección de mi baselink

File: roma_description/urdf/roma.urdf.xacro (robot description, xacro)
@@ -56,5 +56,5 @@
   </xacro:macro>
 <!-- Links -->
-  <link name="base_link">
+  <link name="base_link"/>
   <link name="shell_link">
     <xacro:mesh_collision
